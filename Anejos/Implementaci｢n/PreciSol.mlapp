classdef PreciSol < matlab.apps.AppBase

    % Properties that correspond to app components
    properties (Access = public)
        PreciSolApp             matlab.ui.Figure                   % PreciSol
        Graficas                matlab.ui.container.TabGroup       % I-V, P...
        IV                      matlab.ui.container.Tab            % I-V
        IVGraph                 matlab.ui.control.UIAxes           % Corrie...
        PV                      matlab.ui.container.Tab            % P-V
        PVGraph                 matlab.ui.control.UIAxes           % Potenc...
        T                       matlab.ui.container.Tab            % T
        TGraph                  matlab.ui.control.UIAxes           % Temper...
        G                       matlab.ui.container.Tab            % G
        GGraph                  matlab.ui.control.UIAxes           % Irradi...
        Pot                     matlab.ui.container.Tab            % Potenc...
        PotGraph                matlab.ui.control.UIAxes           % Potenc...
        Datos                   matlab.ui.container.Tab            % Datos
        LabelNumericEditField2  matlab.ui.control.Label            % Potenc...
        PotenciaAcumulada       matlab.ui.control.NumericEditField % [-Inf ...
        PotenciaAcumuladaUnidad matlab.ui.control.EditField       
        RendSTCUnidad           matlab.ui.control.EditField       
        Label4                  matlab.ui.control.Label            % Rendim...
        RendSTC                 matlab.ui.control.NumericEditField % [-Inf ...
        RendObtUnidad           matlab.ui.control.EditField       
        Label5                  matlab.ui.control.Label            % Rend. ...
        RendObt                 matlab.ui.control.NumericEditField % [-Inf ...
        RendAvgUnidad           matlab.ui.control.EditField       
        Label6                  matlab.ui.control.Label            % Rendim...
        RendAvg                 matlab.ui.control.NumericEditField % [-Inf ...
        PotSTCUnidad            matlab.ui.control.EditField       
        Label22                 matlab.ui.control.Label            % Potenc...
        PotSTC                  matlab.ui.control.NumericEditField % [-Inf ...
        Utilidades              matlab.ui.container.Tab            % Utilid...
        Label20                 matlab.ui.control.Label            % File f...
        FileFuser               matlab.ui.control.Button           % Fusion...
        Label23                 matlab.ui.control.Label            % Calcul...
        CalcRes1                matlab.ui.control.Button           % 1 diodo
        CalcRes2                matlab.ui.control.Button           % 2 diodos
        TempModulo              matlab.ui.container.Tab            % Tc
        TcGraph                 matlab.ui.control.UIAxes           % Temper...
        TensionPmax             matlab.ui.container.Tab            % V
        TensGraph               matlab.ui.control.UIAxes           % Tensió...
        CorrientePmax           matlab.ui.container.Tab            % I
        CorrGraph               matlab.ui.control.UIAxes           % Corrie...
        Simular                 matlab.ui.control.Button           % Simular
        Label                   matlab.ui.control.Label            % Simula...
        MeteoData               matlab.ui.container.Panel          % Datos ...
        CargarData              matlab.ui.control.Button           % Cargar
        EliminarData            matlab.ui.control.Button           % Eliminar
        LabelListBox2           matlab.ui.control.Label            % Archivos
        ListaData               matlab.ui.control.ListBox         
        LabelDropDown2          matlab.ui.control.Label            % Mes
        ComienzoMes             matlab.ui.control.DropDown         % Enero,...
        Label3                  matlab.ui.control.Label            % Día
        ComienzoDia             matlab.ui.control.DropDown         % 1, 2, ...
        FechaMode               matlab.ui.container.ButtonGroup    % Modo
        ModoHora                matlab.ui.control.RadioButton      % Hora
        ModoMinuto              matlab.ui.control.RadioButton      % Minuto
        Label16                 matlab.ui.control.Label            % Mes
        FinalMes                matlab.ui.control.DropDown         % Enero,...
        Label17                 matlab.ui.control.Label            % Día
        FinalDia                matlab.ui.control.DropDown         % 1, 2, ...
        Label18                 matlab.ui.control.Label            % Comienzo
        Label19                 matlab.ui.control.Label            % Final
        Modulos                 matlab.ui.container.Panel          % Módulos
        CargarModulos           matlab.ui.control.Button           % Cargar
        EliminarModulos         matlab.ui.control.Button           % Eliminar
        Label2                  matlab.ui.control.Label            % Tipos
        ListaModulos            matlab.ui.control.ListBox         
        ModeloModulo            matlab.ui.control.EditField       
        LabelNumericEditField4  matlab.ui.control.Label            % Voc (V)
        ModuloVoc               matlab.ui.control.NumericEditField % [-Inf ...
        Label7                  matlab.ui.control.Label            % Isc (A)
        ModuloIsc               matlab.ui.control.NumericEditField % [-Inf ...
        Label8                  matlab.ui.control.Label            % Ki
        ModuloKi                matlab.ui.control.NumericEditField % [-Inf ...
        Label9                  matlab.ui.control.Label            % Kv
        ModuloKv                matlab.ui.control.NumericEditField % [-Inf ...
        Label10                 matlab.ui.control.Label            % Ns
        ModuloNs                matlab.ui.control.NumericEditField % [-Inf ...
        Label11                 matlab.ui.control.Label            % TONC
        ModuloTONC              matlab.ui.control.NumericEditField % [-Inf ...
        Label12                 matlab.ui.control.Label            % Vmp
        ModuloVmp               matlab.ui.control.NumericEditField % [-Inf ...
        Label13                 matlab.ui.control.Label            % Imp
        ModuloImp               matlab.ui.control.NumericEditField % [-Inf ...
        Label14                 matlab.ui.control.Label            % μ (%)
        ModuloRend              matlab.ui.control.NumericEditField % [-Inf ...
        Label15                 matlab.ui.control.Label            % Pmp
        ModuloPmp               matlab.ui.control.NumericEditField % [-Inf ...
        Label21                 matlab.ui.control.Label            % Superf...
        ModuloSup               matlab.ui.control.NumericEditField % [-Inf ...
        DatosSimulacion         matlab.ui.container.TabGroup       % Simula...
        DatosBasicos            matlab.ui.container.Tab            % Simula...
        LabelDiscreteKnob       matlab.ui.control.Label            % Precisión
        Precision               matlab.ui.control.DiscreteKnob     % 10, 10...
        Modelo                  matlab.ui.container.ButtonGroup    % Modelo...
        Diodo1Modelo            matlab.ui.control.RadioButton      % Modelo...
        Diodo2Modelo            matlab.ui.control.RadioButton      % Modelo...
        DatosPerdidas           matlab.ui.container.Tab            % Pérdidas
        LabelNumericEditField5  matlab.ui.control.Label            % Pérdid...
        PerFab                  matlab.ui.control.NumericEditField % [0 10]
        Label24                 matlab.ui.control.Label            % Pérdid...
        PerVid                  matlab.ui.control.NumericEditField % [0 25]
        Label25                 matlab.ui.control.Label            % Pérdid...
        PerSuc                  matlab.ui.control.NumericEditField % [0 100]
        Label26                 matlab.ui.control.Label            % Estocá...
        PerFabRand              matlab.ui.control.CheckBox        
        PerVidRand              matlab.ui.control.CheckBox        
        PerSucRand              matlab.ui.control.CheckBox        
        Tab                     matlab.ui.container.Tab            % Nº de ...
        LabelNumericEditField   matlab.ui.control.Label            % M. en ...
        ModulosSerie            matlab.ui.control.NumericEditField % [1 Inf]
        Label27                 matlab.ui.control.Label            % M. en ...
        ModulosParalelo         matlab.ui.control.NumericEditField % [1 Inf]
        LabelNumericEditField6  matlab.ui.control.Label            % M. tot...
        NumeroModulos           matlab.ui.control.NumericEditField % [-Inf ...
        Label28                 matlab.ui.control.Label            % Voltaj...
        VoltMax                 matlab.ui.control.NumericEditField % [-Inf ...
        Label29                 matlab.ui.control.Label            % Corrie...
        IntMax                  matlab.ui.control.NumericEditField % [-Inf ...
        Label30                 matlab.ui.control.Label            % Voltaj...
        VoltAvg                 matlab.ui.control.NumericEditField % [-Inf ...
        Label31                 matlab.ui.control.Label            % Corrie...
        IntAvg                  matlab.ui.control.NumericEditField % [-Inf ...
        VoltMaxUnidad           matlab.ui.control.EditField       
        VoltAvgUnidad           matlab.ui.control.EditField       
        IntMaxUnidad            matlab.ui.control.EditField       
        IntAvgUnidad            matlab.ui.control.EditField       
        Label32                 matlab.ui.control.Label            % Multip...
        MultiplicadorModulos    matlab.ui.control.NumericEditField % [1 Inf]
    end

    
    properties (Access = private)
        DataFileNames = cell(0) % Lista con los nombres de los ficheros de datos meteorológicos cargados
        DataFilePaths = cell(0) % Lista con las rutas de los ficheros de datos meteorológicos cargados
        ModuleFileNames = cell(0) % Lista con los nombres de los ficheros de parámetros de módulo cargados
        ModuleFilePaths = cell(0) % Lista con las rutas de los ficheros de parámetros de módulo cargados
        G_Gh = 0 % Variable vector con los datos de irradiancia globobtenidos del fichero de dat. meteo.
        Ta = 0 % Variable vector con los datos de temp. ambiente obtenidos del fichero de dat. meteo.
        ModuleName = '' % Variable con el nombre del módulo cargado
        Rend = 0 % Var. con el rendimiento del módulo cargado
        Voc = 0 % Var. con la tens. de cir. abierto del módulo cargado
        Isc = 0 % Var. con la corr. de cortocircuito del módulo cargado
        Pmp = 0 % Var. con la potencia máx. del módulo cargado
        Imp = 0 % Var. con la corriente de P.M. del módulo cargado
        Vmp = 0 % Var. con la tensión de P.M. del módulo cargado
        Ns = 0 % Var. con el nº de células del módulo cargado
        Kv = 0 % Var. con el coef. de temp. sobre Voc del módulo cargado
        Ki = 0 % Var. con el coef. de temp. sobre Isc del módulo cargado
        Rs = 0 % Var. vector con la res. en serie del módulo cargado para los dos modelos
        Rp = 0 % Var. vector con la res. en paralelo del módulo cargado para los dos modelos
        TONC = 0 % Var. con la Temperatura de operación nominal del módulo cargado
        Sup = 0 % Var. con la superficie del módulo cargado
    end
    

    methods (Access = private)

        % Code that executes after component creation
        function startupFcn(app)
            % Carga de los dos modelos de SIMULINK de 1 diodo y
            % dos diodos
            load_system('sim_1_diode'); % 1 diodo
            load_system('sim_2_diode'); % 2 diodos
        end

        % CargarData button pushed function
        function CargarDataButtonPushed(app)
            % Seleccionar fichero de datos
            [aux_name, aux_path] = uigetfile('.dat');
            % Añadimos un hueco más a la lista de nombres de ficheros
            % de datos
            aux_size = size(app.DataFileNames);
            aux_size = aux_size(2);
            app.DataFileNames{aux_size + 1} = [];
            app.DataFilePaths{aux_size + 1} = [];
            % Escribimos en los nuevos elementos
            aux_size = size(app.DataFileNames);
            aux_size = aux_size(2);
            app.DataFileNames{aux_size} = aux_name;
            app.DataFilePaths{aux_size} = aux_path;
            % Actualizado de la lista gráfica
            app.ListaData.Items = app.DataFileNames;
        end

        % EliminarData button pushed function
        function EliminarDataButtonPushed(app)
            % Detección de elemento a eliminar
            to_delete = app.ListaData.Value;
            % Determinamos tamaño de la lista
            aux_size = size(app.DataFileNames);
            aux_size = aux_size(2);
            % Encontrar nombre de la lista a eliminar
            index_mat = strfind(app.DataFileNames, to_delete);
            for i = 1:length(index_mat)
                if (index_mat{i} == 1)
                    index_aux = i;
                    break;
                end
            end
            % Borrado del elemento de la lista
            app.DataFileNames = {app.DataFileNames{1:index_aux-1}, ...
                app.DataFileNames{index_aux+1:aux_size}};
            app.DataFilePaths = {app.DataFilePaths{1:index_aux-1}, ...
                app.DataFilePaths{index_aux+1:aux_size}};
            % Actualizado de la lista gráfica
            app.ListaData.Items = app.DataFileNames;
        end

        % CargarModulos button pushed function
        function CargarModulosButtonPushed(app)
            % Seleccionar fichero de datos de módulo
            [aux_name, aux_path] = uigetfile('.csv');
            % Añadimos un hueco más a la lista de nombres de ficheros
            % de datos de módulo
            aux_size = size(app.ModuleFileNames);
            aux_size = aux_size(2);
            app.ModuleFileNames{aux_size + 1} = [];
            app.ModuleFilePaths{aux_size + 1} = [];
            % Escribimos en los nuevos elementos
            aux_size = size(app.ModuleFileNames);
            aux_size = aux_size(2);
            app.ModuleFileNames{aux_size} = aux_name;
            app.ModuleFilePaths{aux_size} = aux_path;
            
            app.ListaModulos.Items = app.ModuleFileNames;
        end

        % EliminarModulos button pushed function
        function EliminarModulosButtonPushed(app)
            % Detección de elemento a eliminar
            to_delete = app.ListaModulos.Value;
            % Determinamos tamaño de la lista
            aux_size = size(app.ModuleFileNames);
            aux_size = aux_size(2);
            % Encontrar nombre de la lista a eliminar
            index_mat = strfind(app.ModuleFileNames, to_delete);
            for i = 1:length(index_mat)
                if (index_mat{i} == 1)
                    index_aux = i;
                    break;
                end
            end
            % Borrado del elemento de la lista
            app.ModuleFileNames = {app.ModuleFileNames{1:index_aux-1}, ...
                app.ModuleFileNames{index_aux+1:aux_size}};
            app.ModuleFilePaths = {app.ModuleFilePaths{1:index_aux-1}, ...
                app.ModuleFilePaths{index_aux+1:aux_size}};
            % Actualizado de la lista gráfica
            app.ListaModulos.Items = app.ModuleFileNames;
        end

        % Simular button pushed function
        function SimularButtonPushed(app)
            % ------------------------------------------------
            % Función asociada al boton "Simular", ejecuta los
            % modelos correspondientes para los datos
            % meteorológicos seleccionados, utilizando los
            % parámetros de módulo seleccionado, así como el
            % resto de opciónes, como número de paneles,
            % precisión y modelo utilizado
            % ------------------------------------------------
            
            % Selección del modelo de simulación
            if app.Diodo1Modelo.Value == 1 % 1 diodo
                module_mode = false; % Modo
            elseif app.Diodo2Modelo.Value == 1 % 2 diodos
                module_mode = true;
            end
            
            % Creación de los índices de comienzo y final de simulación:
            % Comienzo
            n_month_start = get_month_num(app.ComienzoMes.Value);
            n_day_start = str2double(app.ComienzoDia.Value);
            date_index_start = get_date_index(n_month_start, n_day_start) - 1439;
            % Final
            n_month_end = get_month_num(app.FinalMes.Value);
            n_day_end = str2double(app.FinalDia.Value);
            date_index_end = get_date_index(n_month_end, n_day_end);
            
            if date_index_start > date_index_end ||...
                    length(app.G_Gh) == 0 ||...
                    strcmp(app.ModuleName, '') % Detección de errores
                if date_index_start > date_index_end % Fechas incorrectas
                    prompt='Fecha de comienzo mayor que la final';
                elseif length(app.G_Gh) == 0 % Datos meteo. no cargados
                    prompt='Datos meteorológicos no cargados';
                elseif strcmp(app.ModuleName, '') % Datos de mod. no cargados
                    prompt='Datos de módulo no cargados';
                end
                name = 'ERROR';
                warndlg(prompt, name);
            else
                % Selección de truncado de datos
                if app.ModoHora.Value == 1 % Datos en hora
                    t = date_index_start:60:date_index_end;
                    pot_divider = 1;
                else % Datos en minutos
                    t = date_index_start:date_index_end;
                    pot_divider = 60;
                end
                
                % Comienzo de ejecución de la simulación
                progressbar(0)
                progressbar('Progreso de la simulación')
                % Inicialización de vectores
                P = 0;
                I_pmax = 0;
                V_pmax = 0;
                data_T = 0;
                data_G = 0;
                data_Tc = 0;
                i_aux = 1;
                for i = t
                    % Truncado de datos
                    if app.ModoHora.Value == 1
                        Ta_aux = sum(app.Ta(i:i+60))/60;
                        G_Gh_aux = sum(app.G_Gh(i:i+60))/60;
                    else
                        Ta_aux = app.Ta(i);
                        G_Gh_aux = app.G_Gh(i);
                    end
                    % Aplicación de pérdidas por suciedad
                    G_Gh_aux = G_Gh_aux*(1 - app.PerSuc.Value/100);
                    % Temperatura de célula
                    Tc = 273.15 + Ta_aux + app.TONC*G_Gh_aux;
                    % Ejecución de la simulación de un punto
                    [I, V] = fast_diode(app.Voc, app.Isc, app.Ns, ...
                        app.Kv, app.Ki, app.Rs, app.Rp, G_Gh_aux, ...
                        Tc, str2double(app.Precision.Value), module_mode);
                    % Cálculo de la potencia máxima y tension y corriente en Pmax
                    [I_aux, V_aux] = max_p_point(I, V);
                    V_aux = V_aux*app.ModulosSerie.Value;
                    I_aux = I_aux*app.ModulosParalelo.Value;
                    I_pmax(i_aux) = I_aux;
                    V_pmax(i_aux) = V_aux;
                    P(i_aux) = max(I.*V) * app.NumeroModulos.Value;
                    % Guardado de datos meteorológicos truncados
                    data_T(i_aux) = Ta_aux;
                    data_G(i_aux) = G_Gh_aux;
                    data_Tc(i_aux) = Tc - 273.15;
                    % Avance de barra de progreso e índice auxiliar
                    progressbar((1/length(t))*i_aux);
                    i_aux = i_aux + 1;
                end
                progressbar(1) % Cierre de barra de progreso
                
                % Aplicación de pérdidas a la potencia
                for i = 1:length(P)
                    P(i) = P(i)*(1 - app.PerFab.Value/100);
                    P(i) = P(i)*(1 - (app.PerVid.Value*0.8)/100);
                end
                
                % REPRESENTACIÖN DE DATOS GRÁFICOS
                t = 1:i_aux-1;
                plot(app.PotGraph, t, P); % Potencia Generada
                plot(app.TGraph, t, data_T); % Temp. ambiente
                plot(app.TcGraph, t, data_Tc); % Temp. de módulo
                plot(app.GGraph, t, data_G); % Irradiancia
                plot(app.TensGraph, t, V_pmax); % Tensión Pmax
                plot(app.CorrGraph, t, I_pmax); % Corriente Pmax
                
                % CÁLCULO Y REPRESENTACIÓN DE DATOS NUMÉRICOS
                % Pot. acumulada
                pot_acumulada = sum(P)/pot_divider;
                i_aux = 0;
                while pot_acumulada > 1000 && i_aux < 5
                    pot_acumulada = pot_acumulada/1000;
                    i_aux = i_aux + 1;
                end
                app.PotenciaAcumulada.Value = pot_acumulada;
                switch i_aux
                    case 0;
                        app.PotenciaAcumuladaUnidad.Value = 'W';
                    case 1;
                        app.PotenciaAcumuladaUnidad.Value = 'kW';
                    case 2;
                        app.PotenciaAcumuladaUnidad.Value = 'gW';
                    case 3;
                        app.PotenciaAcumuladaUnidad.Value = 'tW';
                    case 4;
                        app.PotenciaAcumuladaUnidad.Value = 'pW';
                    case 5;
                        app.PotenciaAcumuladaUnidad.Value = 'eW';
                end
                % Rendimiento medio
                rend = sum(P)/(sum(data_G)*app.Sup)*100;
                app.RendAvg.Value = rend/app.NumeroModulos.Value;
                app.RendAvgUnidad.Value = '%';
                % Rendimiento máximo obtenido
                rend = P./(data_G*app.Sup);
                app.RendObt.Value = max(rend)*100/app.NumeroModulos.Value;
                app.RendObtUnidad.Value = '%';
                % Rendimiento STC dado por el fabricante
                [I, V] = fast_diode(app.Voc, app.Isc, app.Ns, app.Kv, app.Ki, ...
                    app.Rs, app.Rp, 1000, 298, 1000, module_mode);
                P_stc = I.*V;
                app.PotSTC.Value = max(P_stc);
                app.PotSTCUnidad.Value = 'W';
                rend = max(P_stc)/(1000*app.Sup)*100;
                app.RendSTC.Value = rend;
                app.RendSTCUnidad.Value = '%';
                % Voltaje máximo
                app.VoltMax.Value = max(V_pmax);
                app.VoltMaxUnidad.Value = 'V';
                % Intensidad máxima
                app.IntMax.Value = max(I_pmax);
                app.IntMaxUnidad.Value = 'A';
                % Voltaje e intensidad medias
                V_total = 0;
                I_total = 0;
                count = 0;
                for i = 1:length(V_pmax)
                    if V_pmax(i) > 0
                       V_total = V_total + V_pmax(i);
                       I_total = I_total + I_pmax(i);
                       count = count + 1;
                    end
                end
                app.VoltAvg.Value = V_total/count;
                app.VoltAvgUnidad.Value = 'V';
                app.IntAvg.Value = I_total/count;
                app.IntAvgUnidad.Value = 'A';
                % Representación de curvas características
                % simuladas del módulo
                plot(app.IVGraph, V, I);
                plot(app.PVGraph, V, P_stc);
                
                % Opción de guardar datos en fichero
                quest = '¿Deseas guardar los resultados en un fichero?';
                name = 'Guardar datos';
                respuesta = questdlg(quest, name, 'Si', 'No', 'No');
                if strcmp(respuesta, 'Si')
                    % Guardado en fichero
                    save_data(data_G, data_T, data_Tc, P, V_pmax, ...
                        I_pmax, n_month_start, n_day_start, ...
                        n_month_end, n_day_end, ...
                        app.ModulosSerie.Value, ...
                        app.ModulosParalelo.Value, ...
                        app.NumeroModulos.Value);
                    prompt = 'Datos guardados!';
                    name = 'Atencion';
                else
                    prompt = 'Datos no guardados!';
                    name = 'Atencion';
                end
                % Mensaje con el resultado de la operación
                warndlg(prompt, name);
            end
        end

        % ListaData value changed function
        function ListaDataValueChanged(app)
            % Detección del fichero seleccionado
            data_to_read = app.ListaData.Value;
            % Busca índice en la lista de ficheros cargados
            index_mat = strfind(app.DataFileNames, data_to_read);
            for i = 1:length(index_mat)
                if (index_mat{i} == 1)
                    index_aux = i;
                    break;
                end
            end
            % Generación ruta del fichero
            data_filename = strcat(app.DataFilePaths{index_aux}, ...
                app.DataFileNames{index_aux});
            % Carga del fichero en memoria
            [app.G_Gh, app.Ta] = meteonorm_file(data_filename);
        end

        % ListaModulos value changed function
        function ListaModulosValueChanged(app)
            % Detección del módulo a usar
            module_to_read = app.ListaModulos.Value;
            % Busca índice en la lista de ficheros cargados
            index_mat = strfind(app.ModuleFileNames, module_to_read);
            for i = 1:length(index_mat)
                if (index_mat{i} == 1)
                    index_aux = i;
                    break;
                end
            end
            % Generación ruta del fichero
            module_filename = strcat(app.ModuleFilePaths{index_aux}, ...
                app.ModuleFileNames{index_aux});
            % Carga del fichero en memoria
            [app.ModuleName, app.Rend, app.Voc, app.Isc, app.Pmp, app.Imp, ...
                app.Vmp, app.Ns, app.Kv, app.Ki, app.Rs, app.Rp, ...
                app.TONC, app.Sup] = read_modulefile(module_filename);
            disp(app.ModuleName);
            % Visualización de los datos en memoria
            app.ModeloModulo.Value = app.ModuleName;
            app.ModuloRend.Value = app.Rend;
            app.ModuloVoc.Value = app.Voc;
            app.ModuloIsc.Value = app.Isc;
            app.ModuloPmp.Value = app.Pmp;
            app.ModuloImp.Value = app.Imp;
            app.ModuloVmp.Value = app.Vmp;
            app.ModuloNs.Value = app.Ns;
            app.ModuloKv.Value = app.Kv;
            app.ModuloKi.Value = app.Ki;
            app.ModuloSup.Value = app.Sup;
        end

        % ComienzoMes value changed function
        function ComienzoMesValueChanged(app, event)
            % Obtención del número de mes
            n_month = get_month_num(app.ComienzoMes.Value);
            % Obtención del nº de días del mes
            n_days = get_days_month(n_month);
            % Creación de la lista de días
            day_list = cell(0);
            for i = 1:n_days
                day_list{i} = num2str(i);
            end
            % Guardado de la lista de días, selección del primero
            app.ComienzoDia.Items = day_list;
            app.ComienzoDia.Value = app.ComienzoDia.Items{1};
        end

        % FinalMes value changed function
        function FinalMesValueChanged(app, event)
            % Obtención del número de mes
            n_month = get_month_num(app.FinalMes.Value);
            % Obtención del nº de días del mes
            n_days = get_days_month(n_month);
            % Creación de la lista de días
            day_list = cell(0);
            for i = 1:n_days
                day_list{i} = num2str(i);
            end
            % Guardado de la lista de días, selección del primero
            app.FinalDia.Items = day_list;
            app.FinalDia.Value = app.FinalDia.Items{1};
        end

        % FileFuser button pushed function
        function FileFuserButtonPushed(app)
            % Ejecución de la utilidad "file_fuser"
            file_fuser();
        end

        % CalcRes1 button pushed function
        function CalcRes1ButtonPushed(app)
            % Generación de ventana de petición de datos
            prompt = {'Voc:', 'Isc:', 'Vmp::', 'Imp:', 'Ns', ...
                'Kv:', 'Ki:'};
            dlg_title = 'Valores módulo';
            num_lines = 1;
            defaultans = {'46.2', '9.48', '37.9', '8.97', '72', ...
                '-143', '5.02'};
            values = inputdlg(prompt,dlg_title,num_lines,defaultans);
            % Guardado de datos en memoria
            Voc_aux = str2double(values{1});
            Isc_aux = str2double(values{2});
            Vmp_aux = str2double(values{3});
            Imp_aux = str2double(values{4});
            Ns_aux = str2double(values{5});
            Kv_aux = str2double(values{6});
            Ki_aux = str2double(values{7});
            % Ejecución del script de cálculo de resistencias
            fast_1_diode_resget(Voc_aux, Isc_aux, Vmp_aux, Imp_aux, ...
                Ns_aux, Kv_aux, Ki_aux);
        end

        % CalcRes2 button pushed function
        function CalcRes2ButtonPushed(app)
             % Generación de ventana de petición de datos
            prompt = {'Voc:', 'Isc:', 'Vmp::', 'Imp:', 'Ns', 'Kv:', ...
                'Ki:'};
            dlg_title = 'Valores módulo';
            num_lines = 1;
            defaultans = {'46.2', '9.48', '37.9', '8.97', '72', ...
                '-143', '5.02'};
            values = inputdlg(prompt,dlg_title,num_lines,defaultans);
            % Guardado de datos en memoria
            Voc_aux = str2double(values{1});
            Isc_aux = str2double(values{2});
            Vmp_aux = str2double(values{3});
            Imp_aux = str2double(values{4});
            Ns_aux = str2double(values{5});
            Kv_aux = str2double(values{6});
            Ki_aux = str2double(values{7});
            % Ejecución del script de cálculo de resistencias
            fast_2_diode_resget(Voc_aux, Isc_aux, Vmp_aux, Imp_aux, ...
                Ns_aux, Kv_aux, Ki_aux);
        end

        % PerFabRand value changed function
        function PerFabRandValueChanged(app)
            % Generación de valor aletorio para
            % pérdidas de potencia de fábrica
            value = app.PerFabRand.Value;
            if value == true
                app.PerFab.Editable = 'off';
                app.PerFab.Value = round((10*rand(1, 1, ...
                    'double'))*100)/100;
            else
                app.PerFab.Editable = 'on';
            end
        end

        % PerVidRand value changed function
        function PerVidRandValueChanged(app)
            % Generación de valor aletorio para
            % pérdidas de potencia de ciclo de vida
            value = app.PerVidRand.Value;
            if value == true
                app.PerVid.Editable = 'off';
                app.PerVid.Value = randi(25);
            else
                app.PerVid.Editable = 'on';
            end
        end

        % PerSucRand value changed function
        function PerSucRandValueChanged(app)
            % Generación de valor aletorio para
            % pérdidas de irradiancia por suciedad
            value = app.PerSucRand.Value;
            if value == true
                app.PerSuc.Editable = 'off';
                app.PerSuc.Value = round((100*rand(1, 1, ...
                    'double'))*100)/100;
            else
                app.PerSuc.Editable = 'on';
            end
        end

        % ModulosSerie value changed function
        function ModulosSerieValueChanged(app)
            app.NumeroModulos.Value = app.ModulosSerie.Value *...
                app.ModulosParalelo.Value *...
                app.MultiplicadorModulos.Value;
        end

        % ModulosParalelo value changed function
        function ModulosParaleloValueChanged(app)
            app.NumeroModulos.Value = app.ModulosSerie.Value *...
                app.ModulosParalelo.Value *...
                app.MultiplicadorModulos.Value;
        end

        % MultiplicadorModulos value changed function
        function MultiplicadorModulosValueChanged(app)
            app.NumeroModulos.Value = app.ModulosSerie.Value *...
                app.ModulosParalelo.Value *...
                app.MultiplicadorModulos.Value;
        end
    end

    % App initialization and construction
    methods (Access = private)

        % Create UIFigure and components
        function createComponents(app)
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            app.PreciSolApp = uifigure;
            app.PreciSolApp.Name = 'PreciSol';
            setAutoResize(app, app.PreciSolApp, true)
            app.Graficas = uitabgroup(app.PreciSolApp);
            app.Graficas.Units = 'pixels';
            app.IV = uitab(app.Graficas);
            app.IV.Units = 'pixels';
            app.IV.Title = 'I-V';
            app.IVGraph = uiaxes(app.IV);
            title(app.IVGraph, 'Corriente-Tensión (V-A)');
            xlabel(app.IVGraph, 'V');
            ylabel(app.IVGraph, 'I');
            app.PV = uitab(app.Graficas);
            app.PV.Units = 'pixels';
            app.PV.Title = 'P-V';
            app.PVGraph = uiaxes(app.PV);
            title(app.PVGraph, 'Potencia (W)');
            xlabel(app.PVGraph, 'P');
            ylabel(app.PVGraph, 'I');
            app.T = uitab(app.Graficas);
            app.T.Units = 'pixels';
            app.T.Title = 'T';
            app.TGraph = uiaxes(app.T);
            title(app.TGraph, 'Temperatura (ºC)');
            xlabel(app.TGraph, 't');
            ylabel(app.TGraph, 'T');
            app.G = uitab(app.Graficas);
            app.G.Units = 'pixels';
            app.G.Title = 'G';
            app.GGraph = uiaxes(app.G);
            title(app.GGraph, 'Irradiancia (W/m2)');
            xlabel(app.GGraph, 't');
            ylabel(app.GGraph, 'G');
            app.Pot = uitab(app.Graficas);
            app.Pot.Units = 'pixels';
            app.Pot.Title = 'Potencia Generada';
            app.PotGraph = uiaxes(app.Pot);
            title(app.PotGraph, 'Potencia generada (W/t)');
            xlabel(app.PotGraph, 't');
            ylabel(app.PotGraph, 'P');
            app.Datos = uitab(app.Graficas);
            app.Datos.Units = 'pixels';
            app.Datos.Title = 'Datos';
            app.LabelNumericEditField2 = uilabel(app.Datos);
            app.LabelNumericEditField2.Text = 'Potencia acumulada';
            app.PotenciaAcumulada = uieditfield(app.Datos, 'numeric');
            app.PotenciaAcumulada.ValueDisplayFormat = '%11.6g';
            app.PotenciaAcumulada.Editable = 'off';
            app.PotenciaAcumuladaUnidad = uieditfield(app.Datos, 'text');
            app.PotenciaAcumuladaUnidad.Editable = 'off';
            app.RendSTCUnidad = uieditfield(app.Datos, 'text');
            app.RendSTCUnidad.Editable = 'off';
            app.Label4 = uilabel(app.Datos);
            app.Label4.Text = 'Rendimiento STC';
            app.RendSTC = uieditfield(app.Datos, 'numeric');
            app.RendSTC.ValueDisplayFormat = '%11.6g';
            app.RendSTC.Editable = 'off';
            app.RendObtUnidad = uieditfield(app.Datos, 'text');
            app.RendObtUnidad.Editable = 'off';
            app.Label5 = uilabel(app.Datos);
            app.Label5.Text = 'Rend. max. obtenido';
            app.RendObt = uieditfield(app.Datos, 'numeric');
            app.RendObt.ValueDisplayFormat = '%11.6g';
            app.RendObt.Editable = 'off';
            app.RendAvgUnidad = uieditfield(app.Datos, 'text');
            app.RendAvgUnidad.Editable = 'off';
            app.Label6 = uilabel(app.Datos);
            app.Label6.Text = 'Rendimiento medio';
            app.RendAvg = uieditfield(app.Datos, 'numeric');
            app.RendAvg.ValueDisplayFormat = '%11.6g';
            app.RendAvg.Editable = 'off';
            app.PotSTCUnidad = uieditfield(app.Datos, 'text');
            app.PotSTCUnidad.Editable = 'off';
            app.Label22 = uilabel(app.Datos);
            app.Label22.Text = 'Potencia STC';
            app.PotSTC = uieditfield(app.Datos, 'numeric');
            app.PotSTC.ValueDisplayFormat = '%11.6g';
            app.PotSTC.Editable = 'off';
            app.Label28 = uilabel(app.Datos);
            app.Label28.Text = 'Voltaje máximo';
            app.VoltMax = uieditfield(app.Datos, 'numeric');
            app.VoltMax.ValueDisplayFormat = '%11.6g';
            app.VoltMax.Editable = 'off';
            app.Label29 = uilabel(app.Datos);
            app.Label29.Text = 'Corriente máxima';
            app.IntMax = uieditfield(app.Datos, 'numeric');
            app.IntMax.ValueDisplayFormat = '%11.6g';
            app.IntMax.Editable = 'off';
            app.Label30 = uilabel(app.Datos);
            app.Label30.Text = 'Voltaje medio';
            app.VoltAvg = uieditfield(app.Datos, 'numeric');
            app.VoltAvg.ValueDisplayFormat = '%11.6g';
            app.VoltAvg.Editable = 'off';
            app.Label31 = uilabel(app.Datos);
            app.Label31.Text = 'Corriente media';
            app.IntAvg = uieditfield(app.Datos, 'numeric');
            app.IntAvg.ValueDisplayFormat = '%11.6g';
            app.IntAvg.Editable = 'off';
            app.VoltMaxUnidad = uieditfield(app.Datos, 'text');
            app.VoltMaxUnidad.Editable = 'off';
            app.VoltAvgUnidad = uieditfield(app.Datos, 'text');
            app.VoltAvgUnidad.Editable = 'off';
            app.IntMaxUnidad = uieditfield(app.Datos, 'text');
            app.IntMaxUnidad.Editable = 'off';
            app.IntAvgUnidad = uieditfield(app.Datos, 'text');
            app.IntAvgUnidad.Editable = 'off';
            app.Utilidades = uitab(app.Graficas);
            app.Utilidades.Units = 'pixels';
            app.Utilidades.Title = 'Utilidades';
            app.Label20 = uilabel(app.Utilidades);
            app.Label20.Text = 'File fuser';
            app.FileFuser = uibutton(app.Utilidades, 'push');
            app.FileFuser.ButtonPushedFcn = createCallbackFcn(app, @FileFuserButtonPushed);
            app.FileFuser.Text = 'Fusionar ficheros';
            app.Label23 = uilabel(app.Utilidades);
            app.Label23.Text = 'Calculador resistencias Rs y Rp';
            app.CalcRes1 = uibutton(app.Utilidades, 'push');
            app.CalcRes1.ButtonPushedFcn = createCallbackFcn(app, @CalcRes1ButtonPushed);
            app.CalcRes1.Text = '1 diodo';
            app.CalcRes2 = uibutton(app.Utilidades, 'push');
            app.CalcRes2.ButtonPushedFcn = createCallbackFcn(app, @CalcRes2ButtonPushed);
            app.CalcRes2.Text = '2 diodos';
            app.TempModulo = uitab(app.Graficas);
            app.TempModulo.Units = 'pixels';
            app.TempModulo.Title = 'Tc';
            app.TcGraph = uiaxes(app.TempModulo);
            title(app.TcGraph, 'Temperatura (ºC)');
            xlabel(app.TcGraph, 't');
            ylabel(app.TcGraph, 'T');
            app.TensionPmax = uitab(app.Graficas);
            app.TensionPmax.Units = 'pixels';
            app.TensionPmax.Title = 'V';
            app.TensGraph = uiaxes(app.TensionPmax);
            title(app.TensGraph, 'Tensión (V)');
            xlabel(app.TensGraph, 't');
            ylabel(app.TensGraph, 'V');
            app.CorrientePmax = uitab(app.Graficas);
            app.CorrientePmax.Units = 'pixels';
            app.CorrientePmax.Title = 'I';
            app.CorrGraph = uiaxes(app.CorrientePmax);
            title(app.CorrGraph, 'Corriente (A)');
            xlabel(app.CorrGraph, 't');
            ylabel(app.CorrGraph, 'A');
            app.Simular = uibutton(app.PreciSolApp, 'push');
            app.Simular.ButtonPushedFcn = createCallbackFcn(app, @SimularButtonPushed);
            app.Simular.Text = 'Simular';
            app.Label = uilabel(app.PreciSolApp);
            app.Label.Text = 'Simulador de célula solar';
            app.MeteoData = uipanel(app.PreciSolApp);
            app.MeteoData.Title = 'Datos meteorológicos';
            app.MeteoData.Units = 'pixels';
            app.CargarData = uibutton(app.MeteoData, 'push');
            app.CargarData.ButtonPushedFcn = createCallbackFcn(app, @CargarDataButtonPushed);
            app.CargarData.Text = 'Cargar';
            app.EliminarData = uibutton(app.MeteoData, 'push');
            app.EliminarData.ButtonPushedFcn = createCallbackFcn(app, @EliminarDataButtonPushed);
            app.EliminarData.Text = 'Eliminar';
            app.LabelListBox2 = uilabel(app.MeteoData);
            app.LabelListBox2.Text = 'Archivos';
            app.ListaData = uilistbox(app.MeteoData);
            app.ListaData.Items = {};
            app.ListaData.ValueChangedFcn = createCallbackFcn(app, @ListaDataValueChanged);
            app.ListaData.Value = {};
            app.LabelDropDown2 = uilabel(app.MeteoData);
            app.LabelDropDown2.Text = 'Mes';
            app.ComienzoMes = uidropdown(app.MeteoData);
            app.ComienzoMes.Items = {'Enero', 'Febrero', 'Marzo', 'Abril', 'Mayo', 'Junio', 'Julio', 'Agosto', 'Septiembre', 'Octubre', 'Noviembre', 'Diciembre'};
            app.ComienzoMes.ValueChangedFcn = createCallbackFcn(app, @ComienzoMesValueChanged, true);
            app.ComienzoMes.Value = 'Enero';
            app.Label3 = uilabel(app.MeteoData);
            app.Label3.Text = 'Día';
            app.ComienzoDia = uidropdown(app.MeteoData);
            app.ComienzoDia.Items = {'1', '2', '3', '4', '5', '6', '7', '8', '9', '10', '11', '12', '13', '14', '15', '16', '17', '18', '19', '20', '21', '22', '23', '24', '25', '26', '27', '28', '29', '30', '31'};
            app.ComienzoDia.Value = '1';
            app.FechaMode = uibuttongroup(app.MeteoData);
            app.FechaMode.Title = 'Modo';
            app.FechaMode.Units = 'pixels';
            app.ModoHora = uiradiobutton(app.FechaMode);
            app.ModoHora.Text = 'Hora';
            app.ModoHora.Value = true;
            app.ModoMinuto = uiradiobutton(app.FechaMode);
            app.ModoMinuto.Text = 'Minuto';
            app.Label16 = uilabel(app.MeteoData);
            app.Label16.Text = 'Mes';
            app.FinalMes = uidropdown(app.MeteoData);
            app.FinalMes.Items = {'Enero', 'Febrero', 'Marzo', 'Abril', 'Mayo', 'Junio', 'Julio', 'Agosto', 'Septiembre', 'Octubre', 'Noviembre', 'Diciembre'};
            app.FinalMes.ValueChangedFcn = createCallbackFcn(app, @FinalMesValueChanged, true);
            app.FinalMes.Value = 'Enero';
            app.Label17 = uilabel(app.MeteoData);
            app.Label17.Text = 'Día';
            app.FinalDia = uidropdown(app.MeteoData);
            app.FinalDia.Items = {'1', '2', '3', '4', '5', '6', '7', '8', '9', '10', '11', '12', '13', '14', '15', '16', '17', '18', '19', '20', '21', '22', '23', '24', '25', '26', '27', '28', '29', '30', '31'};
            app.FinalDia.Value = '1';
            app.Label18 = uilabel(app.MeteoData);
            app.Label18.Text = 'Comienzo';
            app.Label19 = uilabel(app.MeteoData);
            app.Label19.Text = 'Final';
            app.Modulos = uipanel(app.PreciSolApp);
            app.Modulos.Title = 'Módulos';
            app.Modulos.Units = 'pixels';
            app.CargarModulos = uibutton(app.Modulos, 'push');
            app.CargarModulos.ButtonPushedFcn = createCallbackFcn(app, @CargarModulosButtonPushed);
            app.CargarModulos.Text = 'Cargar';
            app.EliminarModulos = uibutton(app.Modulos, 'push');
            app.EliminarModulos.ButtonPushedFcn = createCallbackFcn(app, @EliminarModulosButtonPushed);
            app.EliminarModulos.Text = 'Eliminar';
            app.Label2 = uilabel(app.Modulos);
            app.Label2.Text = 'Tipos';
            app.ListaModulos = uilistbox(app.Modulos);
            app.ListaModulos.Items = {};
            app.ListaModulos.ValueChangedFcn = createCallbackFcn(app, @ListaModulosValueChanged);
            app.ListaModulos.Value = {};
            app.ModeloModulo = uieditfield(app.Modulos, 'text');
            app.ModeloModulo.Editable = 'off';
            app.LabelNumericEditField4 = uilabel(app.Modulos);
            app.LabelNumericEditField4.Text = 'Voc (V)';
            app.ModuloVoc = uieditfield(app.Modulos, 'numeric');
            app.ModuloVoc.Editable = 'off';
            app.Label7 = uilabel(app.Modulos);
            app.Label7.Text = 'Isc (A)';
            app.ModuloIsc = uieditfield(app.Modulos, 'numeric');
            app.ModuloIsc.Editable = 'off';
            app.Label8 = uilabel(app.Modulos);
            app.Label8.Text = 'Ki';
            app.ModuloKi = uieditfield(app.Modulos, 'numeric');
            app.ModuloKi.Editable = 'off';
            app.Label9 = uilabel(app.Modulos);
            app.Label9.Text = 'Kv';
            app.ModuloKv = uieditfield(app.Modulos, 'numeric');
            app.ModuloKv.Editable = 'off';
            app.Label10 = uilabel(app.Modulos);
            app.Label10.Text = 'Ns';
            app.ModuloNs = uieditfield(app.Modulos, 'numeric');
            app.ModuloNs.Editable = 'off';
            app.Label11 = uilabel(app.Modulos);
            app.Label11.Text = 'TONC';
            app.ModuloTONC = uieditfield(app.Modulos, 'numeric');
            app.ModuloTONC.Editable = 'off';
            app.Label12 = uilabel(app.Modulos);
            app.Label12.Text = 'Vmp';
            app.ModuloVmp = uieditfield(app.Modulos, 'numeric');
            app.ModuloVmp.Editable = 'off';
            app.Label13 = uilabel(app.Modulos);
            app.Label13.Text = 'Imp';
            app.ModuloImp = uieditfield(app.Modulos, 'numeric');
            app.ModuloImp.Editable = 'off';
            app.Label14 = uilabel(app.Modulos);
            app.Label14.Text = 'μ (%)';
            app.ModuloRend = uieditfield(app.Modulos, 'numeric');
            app.ModuloRend.Editable = 'off';
            app.Label15 = uilabel(app.Modulos);
            app.Label15.Text = 'Pmp';
            app.ModuloPmp = uieditfield(app.Modulos, 'numeric');
            app.ModuloPmp.Editable = 'off';
            app.Label21 = uilabel(app.Modulos);
            app.Label21.Text = 'Superficie (m^2)';
            app.ModuloSup = uieditfield(app.Modulos, 'numeric');
            app.ModuloSup.Editable = 'off';
            app.DatosSimulacion = uitabgroup(app.PreciSolApp);
            app.DatosSimulacion.Units = 'pixels';
            app.DatosBasicos = uitab(app.DatosSimulacion);
            app.DatosBasicos.Units = 'pixels';
            app.DatosBasicos.Title = 'Simulación';
            app.LabelDiscreteKnob = uilabel(app.DatosBasicos);
            app.LabelDiscreteKnob.Text = 'Precisión';
            app.Precision = uiknob(app.DatosBasicos, 'discrete');
            app.Precision.Items = {'10', '100', '1000', '10000', '100000'};
            app.Precision.Value = '1000';
            app.Modelo = uibuttongroup(app.DatosBasicos);
            app.Modelo.Title = 'Modelo de simulación';
            app.Modelo.Units = 'pixels';
            app.Diodo1Modelo = uiradiobutton(app.Modelo);
            app.Diodo1Modelo.Text = 'Modelo de 1 diodo';
            app.Diodo1Modelo.Value = true;
            app.Diodo2Modelo = uiradiobutton(app.Modelo);
            app.Diodo2Modelo.Text = 'Modelo de 2 diodos';
            app.DatosPerdidas = uitab(app.DatosSimulacion);
            app.DatosPerdidas.Units = 'pixels';
            app.DatosPerdidas.Title = 'Pérdidas';
            app.LabelNumericEditField5 = uilabel(app.DatosPerdidas);
            app.LabelNumericEditField5.Text = 'Pérdida de pot. nom. de fábrica (%)';
            app.PerFab = uieditfield(app.DatosPerdidas, 'numeric');
            app.PerFab.Limits = [0 10];
            app.Label24 = uilabel(app.DatosPerdidas);
            app.Label24.Text = 'Pérdida de pot. por vida útil (años)';
            app.PerVid = uieditfield(app.DatosPerdidas, 'numeric');
            app.PerVid.Limits = [0 25];
            app.Label25 = uilabel(app.DatosPerdidas);
            app.Label25.Text = 'Pérdida de irradiancia por suciedad (%)';
            app.PerSuc = uieditfield(app.DatosPerdidas, 'numeric');
            app.PerSuc.Limits = [0 100];
            app.Label26 = uilabel(app.DatosPerdidas);
            app.Label26.Text = 'Estocástico';
            app.PerFabRand = uicheckbox(app.DatosPerdidas);
            app.PerFabRand.ValueChangedFcn = createCallbackFcn(app, @PerFabRandValueChanged);
            app.PerFabRand.Text = '';
            app.PerVidRand = uicheckbox(app.DatosPerdidas);
            app.PerVidRand.ValueChangedFcn = createCallbackFcn(app, @PerVidRandValueChanged);
            app.PerVidRand.Text = '';
            app.PerSucRand = uicheckbox(app.DatosPerdidas);
            app.PerSucRand.ValueChangedFcn = createCallbackFcn(app, @PerSucRandValueChanged);
            app.PerSucRand.Text = '';
            app.Tab = uitab(app.DatosSimulacion);
            app.Tab.Units = 'pixels';
            app.Tab.Title = 'Nº de módulos e Interconexión';
            app.LabelNumericEditField = uilabel(app.Tab);
            app.LabelNumericEditField.Text = 'M. en serie';
            app.ModulosSerie = uieditfield(app.Tab, 'numeric');
            app.ModulosSerie.ValueChangedFcn = createCallbackFcn(app, @ModulosSerieValueChanged);
            app.ModulosSerie.Limits = [1 Inf];
            app.ModulosSerie.Value = 1;
            app.Label27 = uilabel(app.Tab);
            app.Label27.Text = 'M. en paralelo';
            app.ModulosParalelo = uieditfield(app.Tab, 'numeric');
            app.ModulosParalelo.ValueChangedFcn = createCallbackFcn(app, @ModulosParaleloValueChanged);
            app.ModulosParalelo.Limits = [1 Inf];
            app.ModulosParalelo.Value = 1;
            app.LabelNumericEditField6 = uilabel(app.Tab);
            app.LabelNumericEditField6.Text = 'M. totales';
            app.NumeroModulos = uieditfield(app.Tab, 'numeric');
            app.NumeroModulos.ValueDisplayFormat = '%11.10g';
            app.NumeroModulos.Editable = 'off';
            app.NumeroModulos.Value = 1;
            app.Label32 = uilabel(app.Tab);
            app.Label32.Text = 'Multiplicador';
            app.MultiplicadorModulos = uieditfield(app.Tab, 'numeric');
            app.MultiplicadorModulos.ValueChangedFcn = createCallbackFcn(app, @MultiplicadorModulosValueChanged);
            app.MultiplicadorModulos.Limits = [1 Inf];
            app.MultiplicadorModulos.Value = 1;
        end
    end

    methods (Access = public)

        % Construct app
        function app = PreciSol()

            % Create and configure components
            createComponents(app)

            % Register the app with App Designer
            registerApp(app, app.PreciSolApp)

            % Execute the startup function
            runStartupFcn(app, @startupFcn)

            if nargout == 0
                clear app
            end
        end

        % Code that executes before app deletion
        function delete(app)

            % Delete UIFigure when app is deleted
            delete(app.PreciSolApp)
        end
    end
end